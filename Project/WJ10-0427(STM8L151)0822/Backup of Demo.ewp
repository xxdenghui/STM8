# IAR project Backup of Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K6 STM8L151K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15
  ICCSTM8.CCIncludePath2: ..\..\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\..\Libraries\HAL; ..\..\Libraries\Device; ..\..\Libraries\Bus; ..\..\Libraries\CRC; User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Demo.hex
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Config
    User/: conf.h cpu_cfg.h dev_cfg.h hal_cfg.h stm8l15x_conf.h
  group CRC
    ../../Libraries/CRC/: crc.c
  group HAL
    ../../Libraries/HAL/: hal_uart.c sof_delay.c
  group HAL/STM8L15x_StdPeriph_Driver
    ../../Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_gpio.c stm8l15x_syscfg.c stm8l15x_tim4.c stm8l15x_usart.c
  group User
    User/: main.c stm8l15x_it.c
