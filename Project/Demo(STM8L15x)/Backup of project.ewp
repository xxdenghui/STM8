# IAR project Backup of project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207CB STM8S207CB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S; STM8S207
  ICCSTM8.CCIncludePath2: ..\..\Libraries\STM8S_StdPeriph_Driver\inc; ..\..\Libraries\Device; ..\..\Libraries\HAL; ..\..\Libraries\Bus; ..\..\Libraries\CRC; User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Config
    User/: conf.h cpu_cfg.h dev_cfg.h hal_cfg.h stm8s_conf.h
  group CRC
    ../../Libraries/CRC/: crc.c
  group Device/HAL
    ../../Libraries/HAL/: hal_uart.c sof_delay.c
  group Device/HAL/STM8S_StdPeriph_Driver
    ../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim4.c stm8s_uart1.c stm8s_uart3.c
  group User
    User/: main.c stm8s_it.c
