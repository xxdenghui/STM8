# IAR project Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S; STM8S003
  ICCSTM8.CCIncludePath2: ..\..\Libraries\STM8S_StdPeriph_Driver\inc; ..\..\Libraries\HAL; ..\..\Libraries\Device; ..\..\Libraries\Bus; ..\..\Libraries\CRC; User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Demo.hex
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group Config
    User/: conf.h cpu_cfg.h dev_cfg.h hal_cfg.h stm8s_conf.h
  group Drivers
    ../../Libraries/Device/: ssd1306.c
  group Hal
    ../../Libraries/HAL/: hal_uart.c sof_delay.c
  group Librarys
    ../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_spi.c stm8s_tim4.c stm8s_uart1.c
  group User
    ../../Libraries/CRC/: crc.c
    User/: main.c stm8s_it.c
